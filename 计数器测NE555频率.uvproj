# Keil uVision project 计数器测NE555频率.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 计数器测NE555频率 +hex
  c flags: Optimize=8 SizeSpeed=1
  group User
    ./: main.c Delay.c Delay.h HC138.c HC138.h SMG.c SMG.h Timer.c Timer.h
